options:
  parameters:
    generate_options: no_gui
    id: hack_a_sat
    output_language: python
    run_options: run
    title: Hack-A-Sat Modem
  states: {}

blocks:
- name: band_1_c
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '500'
    step: '10'
    stop: '3500'
    value: '1050'
  states: {state: disabled}
- name: band_1_c
  id: variable
  parameters:
    value: '1050'
  states: {}
- name: band_1_hi
  id: variable
  parameters:
    value: band_1_c + band_span
  states: {}
- name: band_1_lo
  id: variable
  parameters:
    value: band_1_c - band_span
  states: {}
- name: band_2_c
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '500'
    step: '10'
    stop: '3500'
    value: '1750'
  states: {state: disabled}
- name: band_2_c
  id: variable
  parameters:
    value: '1750'
  states: {}
- name: band_2_hi
  id: variable
  parameters:
    value: band_2_c + band_span
  states: {}
- name: band_2_lo
  id: variable
  parameters:
    value: band_2_c - band_span
  states: {}
- name: band_span
  id: variable
  parameters:
    value: '250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: band_1_hi
    low_cutoff_freq: band_1_lo
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: band_2_hi
    low_cutoff_freq: band_2_lo
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lo.u8
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: hi.u8
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -band_1_c / samp_rate
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -band_2_c / samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jboone/Downloads/Hack-A-Sat 2020/modem-sierra38145uniform/recording.wav
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: band_1_c
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: band_2_c
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '16384'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '16384'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [band_pass_filter_0, '0', blocks_rotator_cc_0, '0']
- [band_pass_filter_0_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_rotator_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_rotator_cc_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_rotator_cc_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
